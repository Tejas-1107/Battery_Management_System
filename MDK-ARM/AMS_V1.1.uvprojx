# Keil uVision project AMS_V1.1.uvprojx, settings and files
target AMS_V1.1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32L4R7ZITx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.6.0
  cpu: IRAM(0x20000000-0x2009FFFF) IROM(0x8000000-0x81FFFFF)  CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: AMS_V1.1 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32L4R7xx
  c include: ../Core/Inc;../Drivers/STM32L4xx_HAL_Driver/Inc;../Drivers/STM32L4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32L4xx/Include;../Drivers/CMSIS/Include
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0xa0000
  group Application/MDK-ARM
    ./: startup_stm32l4r7xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c i2c.c stm32l4xx_it.c stm32l4xx_hal_msp.c MAX17320.c MAX_PAGE_000h_00Fh.c MAX_PAGE_010h_01Fh.c MAX_PAGE_020h_02Fh.c MAX17320_SBS_PRTOCOL.c MAX17320_NON_VOLATILE_MEMORY.c SBS_PAGE_100h_10Fh.c MAX_PAGE_030h_03F.c MAX_PAGE_040h_04Fh.c MAX_PAGE_0A0h_0AFh.c MAX_PAGE_0B0h_0BFh.c MAX_PAGE_0D0h_0DFh.c
    ../Core/Inc/: MAX17320.h MAX_PAGE_000h_00Fh.h MAX_PAGE_010h_01Fh.h MAX_PAGE_020h_02Fh.h MAX17320_SBS_PROTOCOL.h MAX17320_NON_VOLATILE_MEMORY.h SBS_PAGE_100h_10Fh.h MAX_PAGE_030h_03F.h MAX_PAGE_040h_04Fh.h MAX_PAGE_0A0h_0AFh.h MAX_PAGE_0B0h_0BFh.h MAX_PAGE_0D0h_0DFh.h
  group Drivers/STM32L4xx_HAL_Driver
    ../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_gpio.c stm32l4xx_hal_dma.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_cortex.c stm32l4xx_hal_exti.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32l4xx.c
software components: CMSIS:CORE 4.3.0
